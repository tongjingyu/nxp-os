# Keil uVision project Project.uvproj, settings and files
target BOARD_HAOYU (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 OneElfS=1
  c define: BOARD_HAOYU
  c include: ..\USER;..\Driver;..\Configs;..\Boot;..\Tos;..\Tools;..\FS\TQFS;..\USER\Prj_4.3LCD;..\USER\Prj_CanBus;..\USER\Prj_Sensor;..\GUI\MGui;..\FuncTask;..\USER\Prj_Really;..\USER\Prj_PdaTran;..\USB\WHID;..\FS;..\GUI\TGui;..\GUI;..\Libraries\Drivers\include;..\Libraries\CMSIS;..\GUI\Application
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group StdPeriph_Driver
    ../Libraries/Drivers/source/: lpc177x_8x_systick.c lpc177x_8x_clkpwr.c lpc177x_8x_emc.c lpc177x_8x_gpio.c lpc177x_8x_lcd.c lpc177x_8x_pinsel.c lpc177x_8x_eeprom.c lpc177x_8x_ssp.c lpc177x_8x_uart.c
  group CMSIS
    ../Libraries/CMSIS/CM3/DeviceSupport/NXP/LPC177x_8x/: system_LPC177x_8x.c
  group Startup
    ../Libraries/Startup/: startup_LPC177x_8x.s
  group Doc
    ../Doc/: record.txt readme.txt
    ../: README.md
  group Board_Driver
    ../Driver/: CPU.c SDRAM_K4S561632C_32M_16BIT.c Usart_Driver.c
  group Configs
    ../Configs/: Include.h Define.h Configs.h
  group Tos
    ../Tos/: Tos.c Tos_timer.c tos_core_a.asm Tos_Include.h LockCode.c Tos_Mema.c Tos_Device.c
  group Tools
    ../Tools/: DeBug.c ModBus.c CheakOut.c Operation.c TTS.c AppConfig.c
  group GUI
    ../GUI/: emWin_516_Keil4_M3_LE.lib GUI_X.c GUIConf.c LCDConf.c
  group Main
    ../USER/: Main.c
