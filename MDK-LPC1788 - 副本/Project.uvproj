# Keil uVision project Project.uvproj, settings and files
target BOARD_HAOYU (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Project +hex (library)
  c flags: Optim=1 OneElfS=1
  c define: BOARD_HAOYU
  c include: ..\USER;..\Driver;..\Configs;..\Boot;..\Tos;..\Tools;..\FS\TQFS;..\USER\Prj_4.3LCD;..\USER\Prj_CanBus;..\USER\Prj_Sensor;..\GUI\MGui;..\FuncTask;..\USER\Prj_Really;..\USER\Prj_PdaTran;..\USB\WHID;..\FS;..\GUI\TGui;..\GUI;..\Libraries\Drivers\include;..\Libraries\CMSIS;..\GUI\Application;..\FS\EFSL\inc;..\FS\EFSL\conf;..\FS\EFSL\inc\interfaces;..\FS\EFSL\main
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Tos
    ../Tos/: Tos.c Tos_timer.c tos_core_a.asm Tos_Include.h LockCode.c Tos_Mema.c Tos_Device.c SDRAM_Mema.c
